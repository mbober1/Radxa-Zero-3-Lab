PACKAGECONFIG:append =  " dbus evdev widgets tools libs linuxfb gles2 \
    examples teststools accessibility eglfs fontconfig tslib"