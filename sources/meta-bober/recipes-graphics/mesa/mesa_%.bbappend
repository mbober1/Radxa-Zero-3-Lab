PACKAGECONFIG:append = " kmsro panfrost"
