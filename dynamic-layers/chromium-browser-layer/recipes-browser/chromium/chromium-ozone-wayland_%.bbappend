PACKAGECONFIG = "kiosk-mode proprietary-codecs use-egl use-vaapi"