PACKAGECONFIG:append = "sensors"
